// G22A: a TUNE offer is accepted only with a valid RSA-3072 PKCS#1 v1.5 SHA-256 signature
// over the stick's own nonce, an expiry and the command list (adapters/tune/session.hpp,
// offer_rsa.hpp). The key pairs here are generated by this check on every run (mbedtls,
// fixed test seed); the owner's signing key is never involved. The verification code is the
// one the board compiles; the library is the mbedtls of the pinned ESP-IDF checkout.
#include "check.hpp"
#include "offer_rsa.hpp"
#include <cstring>
#include <string>
#include <vector>
#include "mbedtls/rsa.h"
#include "mbedtls/sha256.h"

using namespace guardian::tune::wifi;

namespace {
// Test-only generator (xorshift64): repeatable keys, nothing secret to protect.
int test_rng(void* state, unsigned char* out, size_t n) {
    auto& s = *static_cast<std::uint64_t*>(state);
    for (size_t i = 0; i < n; ++i) { s ^= s << 13; s ^= s >> 7; s ^= s << 17; out[i] = static_cast<unsigned char>(s >> 24); }
    return 0;
}
struct Pair {
    mbedtls_rsa_context rsa;
    std::uint64_t seed;
    bool made{};
    Pair(std::uint64_t s, unsigned bits = 3072) : seed(s) {
        mbedtls_rsa_init(&rsa);
        made = mbedtls_rsa_gen_key(&rsa, test_rng, &seed, bits, 65537) == 0;
    }
    ~Pair() { mbedtls_rsa_free(&rsa); }
    Pair(const Pair&) = delete; Pair& operator=(const Pair&) = delete;
    std::vector<std::uint8_t> modulus() const {
        std::vector<std::uint8_t> n(mbedtls_rsa_get_len(&rsa));
        if (mbedtls_rsa_export_raw(&rsa, n.data(), n.size(), nullptr, 0, nullptr, 0, nullptr, 0, nullptr, 0) != 0) n.clear();
        return n;
    }
    // "<text>sig=<hex>\n": what tools/tune_session.py appends with the owner's key.
    std::string sign(const std::string& text) {
        std::uint8_t digest[32]; std::vector<std::uint8_t> sig(mbedtls_rsa_get_len(&rsa));
        mbedtls_sha256(reinterpret_cast<const std::uint8_t*>(text.data()), text.size(), digest, 0);
        if (mbedtls_rsa_pkcs1_sign(&rsa, test_rng, &seed, MBEDTLS_MD_SHA256, sizeof digest, digest, sig.data()) != 0) return text;
        static const char* hex = "0123456789abcdef";
        std::string out = text + "sig=";
        for (auto b : sig) { out += hex[b >> 4]; out += hex[b & 15]; }
        return out + "\n";
    }
};
Pair& owner() { static Pair p(0x9E3779B97F4A7C15ull); return p; }       // stands in for the OTA signing key
Pair& stranger() { static Pair p(0xD1B54A32D192ED03ull); return p; }    // any other key

const char* kNonce = "a0a1a2a3a4a5a6a7a8a9aaabacadaeaf";
Nonce stick_nonce(std::uint32_t at = 5000) {
    std::uint8_t r[kNonceBytes]; for (std::size_t i = 0; i < kNonceBytes; ++i) r[i] = static_cast<std::uint8_t>(0xa0 + i);
    return make_nonce(r, at);
}
std::string body(const char* nonce = kNonce, const char* commands = "cmd=TUNE detect.burst=6\ncmd=STATUS\n", const char* expires = "60") {
    return std::string("GUARDIAN-TUNE 2\nnonce=") + nonce + "\nexpires=" + expires + "\n" + commands + "end\n";
}
RsaKey stick_key() { RsaKey k; const auto n = owner().modulus(); k.load(n.data(), n.size(), 65537); return k; }
Refusal check(const std::string& text, Offer& o, const RsaKey& key, std::uint32_t now = 6000) {
    return verify_offer(text.data(), text.size(), stick_nonce(), now, &key, o);
}
}

GUARDIAN_CASE(test_key_pairs_are_generated_here) {
    CHECK(owner().made); CHECK(stranger().made);
    CHECK_EQ(owner().modulus().size(), kSignatureBytes); CHECK(owner().modulus() != stranger().modulus());
    const RsaKey k = stick_key(); CHECK(k.loaded());
}

GUARDIAN_CASE(offer_signed_with_the_key_is_accepted) {
    const RsaKey key = stick_key(); Offer o;
    const std::string text = owner().sign(body());
    CHECK(text.size() > body().size() + 2 * kSignatureBytes);
    CHECK(check(text, o, key) == Refusal::None);
    CHECK_EQ(std::string(o.session.data()), std::string(kNonce)); CHECK_EQ(o.seconds, 60u); CHECK_EQ(int(o.command_count), 2);
    if (o.command_count == 2) {
        CHECK_EQ(std::string(o.commands[0].data()), std::string("TUNE detect.burst=6"));
        CHECK_EQ(std::string(o.commands[1].data()), std::string("STATUS"));
    }
    // The stick's key as its signature block stores it (least significant byte first) is the same key.
    auto le = owner().modulus(); std::vector<std::uint8_t> rev(le.rbegin(), le.rend());
    RsaKey from_block; CHECK(from_block.load_le(rev.data(), rev.size(), 65537)); CHECK(check(text, o, from_block) == Refusal::None);
}

GUARDIAN_CASE(bad_signature_is_refused) {
    const RsaKey key = stick_key(); Offer keep; keep.seconds = 77;
    const std::string good = owner().sign(body());
    // Signed by another key.
    CHECK(check(stranger().sign(body()), keep, key) == Refusal::Signature);
    // One bit of the signature changed.
    std::string flipped = good; const auto at = flipped.rfind("sig=") + 4 + 100; flipped[at] = flipped[at] == '0' ? '1' : '0';
    CHECK(check(flipped, keep, key) == Refusal::Signature);
    // The owner's signature moved onto other commands, another expiry or another nonce's text.
    const std::string sig = good.substr(good.rfind("sig="));
    CHECK(check(body(kNonce, "cmd=TUNE detect.burst=128\ncmd=STATUS\n") + sig, keep, key) == Refusal::Signature);
    CHECK(check(body(kNonce, "cmd=TUNE detect.burst=6\ncmd=STATUS\n", "1800") + sig, keep, key) == Refusal::Signature);
    CHECK(check(body(kNonce, "cmd=TUNE detect.burst=6\ncmd=STATUS\ncmd=TUNE save\n") + sig, keep, key) == Refusal::Signature);
    // A signature of all zeros or all ones.
    CHECK(check(body() + "sig=" + std::string(2 * kSignatureBytes, '0') + "\n", keep, key) == Refusal::Signature);
    CHECK(check(body() + "sig=" + std::string(2 * kSignatureBytes, 'f') + "\n", keep, key) == Refusal::Signature);
    CHECK_EQ(keep.seconds, 77u);
    CHECK(check(good, keep, key) == Refusal::None);   // control
}

GUARDIAN_CASE(unsigned_offer_is_refused) {
    const RsaKey key = stick_key(); Offer keep; keep.seconds = 77;
    CHECK(check(body(), keep, key) == Refusal::Unsigned);
    CHECK(check("GUARDIAN-TUNE 1\nsession=0123456789abcdef\nseconds=300\nend\n", keep, key) == Refusal::Unsigned);
    CHECK_EQ(keep.seconds, 77u);
}

GUARDIAN_CASE(wrong_nonce_is_refused_so_a_recorded_offer_cannot_be_replayed) {
    const RsaKey key = stick_key(); Offer o;
    const std::string recorded = owner().sign(body());   // valid for the poll that drew kNonce
    CHECK(check(recorded, o, key) == Refusal::None);
    // The next poll draws a new nonce: the same bytes, perfectly signed, open nothing.
    std::uint8_t r[kNonceBytes]; for (std::size_t i = 0; i < kNonceBytes; ++i) r[i] = static_cast<std::uint8_t>(0x10 + i);
    const Nonce next = make_nonce(r, 125000);
    Offer keep; keep.seconds = 77;
    CHECK(verify_offer(recorded.data(), recorded.size(), next, 125500, &key, keep) == Refusal::Nonce);
    CHECK_EQ(keep.seconds, 77u);
}

GUARDIAN_CASE(expired_offer_is_refused) {
    const RsaKey key = stick_key(); Offer keep; keep.seconds = 77;
    const std::string text = owner().sign(body(kNonce, "cmd=STATUS\n", "30"));   // nonce drawn at 5000 ms
    Offer o; CHECK(check(text, o, key, 34999) == Refusal::None);
    CHECK(check(text, keep, key, 35000) == Refusal::Expired);
    CHECK_EQ(keep.seconds, 77u);
}

GUARDIAN_CASE(signed_command_outside_the_allowlist_is_refused) {
    const RsaKey key = stick_key(); Offer keep; keep.seconds = 77;
    CHECK(check(owner().sign(body(kNonce, "cmd=OTA SSID 41\n")), keep, key) == Refusal::Command);
    CHECK_EQ(keep.seconds, 77u);
}

GUARDIAN_CASE(key_of_another_size_or_shape_is_not_loaded) {
    RsaKey k; const auto n = owner().modulus();
    CHECK(!k.load(n.data(), n.size() - 1, 65537)); CHECK(!k.loaded());
    CHECK(!k.load(nullptr, n.size(), 65537));
    CHECK(!k.load(n.data(), n.size(), 0)); CHECK(!k.load(n.data(), n.size(), 1)); CHECK(!k.load(n.data(), n.size(), 65536));
    auto even = n; even.back() &= 0xFE; CHECK(!k.load(even.data(), even.size(), 65537));
    auto small = n; small.front() &= 0x7F; CHECK(!k.load(small.data(), small.size(), 65537));
    std::vector<std::uint8_t> zero(n.size(), 0); CHECK(!k.load(zero.data(), zero.size(), 65537)); CHECK(!k.loaded());
    // No key loaded: every offer is refused at the signature, never accepted.
    Offer keep; keep.seconds = 77;
    CHECK(check(owner().sign(body()), keep, k) == Refusal::Signature); CHECK_EQ(keep.seconds, 77u);
    // A 2048-bit key cannot stand in for the 3072-bit one.
    Pair shorter(0x1234567887654321ull, 2048); CHECK(shorter.made);
    const auto n2 = shorter.modulus(); CHECK(!k.load(n2.data(), n2.size(), 65537));
}

GUARDIAN_CASE(key_is_read_from_a_secure_boot_v2_signature_block) {
    CHECK_EQ(crc32(reinterpret_cast<const std::uint8_t*>("123456789"), 9), 0xCBF43926u);   // the CRC-32 check value
    // A block as espsecure writes it: magic, version 2 (RSA), digest, modulus (least significant byte first),
    // exponent, Montgomery values and the image signature (not used here), CRC-32 of the first 1196 bytes.
    std::vector<std::uint8_t> block(kSignatureBlockBytes, 0x5a);
    block[0] = 0xE7; block[1] = 2; block[2] = 0; block[3] = 0;
    const auto n = owner().modulus();
    for (std::size_t i = 0; i < n.size(); ++i) block[36 + i] = n[n.size() - 1 - i];
    block[420] = 0x01; block[421] = 0x00; block[422] = 0x01; block[423] = 0x00;   // 65537
    const auto seal = [&block] { const auto c = crc32(block.data(), 1196); for (int i = 0; i < 4; ++i) block[1196 + i] = static_cast<std::uint8_t>(c >> (8 * i)); };
    seal();
    RsaKey key; CHECK(key.load_signature_block(block.data(), block.size())); CHECK(key.loaded());
    Offer o; CHECK(check(owner().sign(body()), o, key) == Refusal::None);
    Offer keep; keep.seconds = 77;
    CHECK(check(stranger().sign(body()), keep, key) == Refusal::Signature);
    // Not a valid block: nothing is loaded and an earlier key is dropped.
    RsaKey k = stick_key(); CHECK(k.loaded());
    CHECK(!k.load_signature_block(block.data(), block.size() - 1)); CHECK(!k.loaded());
    CHECK(!k.load_signature_block(nullptr, block.size()));
    auto bad = block; bad[0] = 0xE6; CHECK(!k.load_signature_block(bad.data(), bad.size()));              // magic
    bad = block; bad[40] ^= 1; CHECK(!k.load_signature_block(bad.data(), bad.size()));                     // a key bit changed: CRC
    bad = block; bad[1196] ^= 1; CHECK(!k.load_signature_block(bad.data(), bad.size()));                   // the CRC itself
    const auto resealed = [&](std::size_t at, std::uint8_t value) { auto keep_block = block; block[at] = value; seal(); auto out = block; block = keep_block; return out; };
    bad = resealed(1, 3); CHECK(!k.load_signature_block(bad.data(), bad.size()));                          // another scheme (ECDSA), CRC valid
    bad = resealed(420, 0x00); CHECK(!k.load_signature_block(bad.data(), bad.size()));                     // even exponent, CRC valid
    std::vector<std::uint8_t> erased(kSignatureBlockBytes, 0xFF); CHECK(!k.load_signature_block(erased.data(), erased.size()));   // erased flash
    CHECK(!k.loaded()); CHECK_EQ(keep.seconds, 77u);
}
